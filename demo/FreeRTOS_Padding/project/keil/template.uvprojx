# Keil uVision project template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EE
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\..\..\..\portable\startlib\stm32f40_41xxx_start;..\..\..\..\portable\fwlib\stm32f4xx_lib\inc;..\..\..\..\portable\bsplib\zdyz_explorer_bsp;..\..\..\..\portable\startlib\stm32f40_41xxx_start\portable\keil;..\..\..\..\components\FreeRTOS-Kernel-V9.0.0\include;..\..\..\..\components\FreeRTOS-Kernel-V9.0.0\portable\RVDS\ARM_CM4F;..\..\app;..\..\..\..\components\SystemView-V3.3\SEGGER;..\..\..\..\components\SystemView-V3.3\Sample\FreeRTOSV9;..\..\..\..\components\SystemView-V3.3\Sample\FreeRTOSV9\Config\Cortex-M;..\..\..\..\components\SystemView-V3.3\Config;..\..\config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../../../../portable/startlib/stm32f40_41xxx_start/: system_stm32f4xx.c
    ../../../../portable/startlib/stm32f40_41xxx_start/portable/keil/: startup_stm32f40_41xxx.s Retarget.c
    ../../config/: pad_stm32f4xx_it.c
  group fwlib
    ../../../../portable/fwlib/stm32f4xx_lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group bsplib
    ../../../../portable/bsplib/zdyz_explorer_bsp/: bsp_tim6.c bsp_uart1.c
  group main
    ../../app/: main.c
  group COM_freertos
    ../../config/: FreeRTOSConfig.h
    ../../../../components/FreeRTOS-Kernel-Padding/: list.c queue.c tasks.c timers.c
    ../../../../components/FreeRTOS-Kernel-Padding/portable/RVDS/ARM_CM4F/: port.c
    ../../../../components/FreeRTOS-Kernel-Padding/portable/MemMang/: heap_4.c
  group COM_systemview
    ../../../../components/SystemView-V3.3/Config/: SEGGER_SYSVIEW_Conf.h
    ../../../../components/SystemView-V3.3/Sample/FreeRTOSV9/Config/Cortex-M/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../../../../components/SystemView-V3.3/Sample/FreeRTOSV9/: SEGGER_SYSVIEW_FreeRTOS.c
    ../../../../components/SystemView-V3.3/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
  group app
    ../../app/: app_hello.cpp
